
FILESEXTRAPATHS_prepend_arm := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://custom.scc \
	file://custom_update \
	"

